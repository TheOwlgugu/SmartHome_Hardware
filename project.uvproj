# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: common.h delay.c delay.h main.c uart.c uart.h led.c led.h motor.c motor.h device.c device.h esp8266.c esp8266.h key.c key.h
